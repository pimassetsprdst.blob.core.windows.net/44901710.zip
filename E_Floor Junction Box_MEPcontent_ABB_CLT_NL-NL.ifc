Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Numéro de projet
Time: 2023-07-19T17:22:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.2.1.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 19 17:22:32 2023 * Host: DFILIPO-RO-LE1 * Database: C:\Users\DFilipo\AppData\Local\Temp\4e22d3b3-d3f8-4c11-a8e0-52057c453fd8\477a75cc-f2f6-4646-9b4b-af1da3a7ae17\ifc * Database version: 5507 * Database creation date: Wed Jul 19 17:22:30 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jul 19 17:22:31 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 19 17:22:31 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro de projet
LongName: Projet Description; Phase: État du projet

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Nom du client; Project Address: Entrez l'adresse ici; Project Issue Date: Date de demande; Project Name: Projet Description; Project Number: Numéro de projet; Project Status: État du projet

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Nom du client; Project Address: Entrez l'adresse ici; Project Issue Date: Date de demande; Project Name: Projet Description; Project Number: Numéro de projet; Project Status: État du projet

# IfcBuildingStorey: Level:niveau du sol, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: niveau du sol
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_LEVEL_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: niveau du sol
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: niveau du sol; Family and Type: Level: niveau du sol; Type: Level: niveau du sol; Type Id: Level: niveau du sol

# IfcDistributionPort (8)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcJunctionBox: E_Floor Junction Box_Cover_MEPcontent_ABB_FB CLT-C_NL-NL_Shared:FB CLT-C, E_Floor Junction Box_Cover_MEPcontent_ABB_FB CLT-C_NL-NL_Shared:FB CLT-C:1375233
In: V00
Type - Classification: ﻿﻿ ﻿ ​ ​﻿ ﻿ ﻿ ﻿ ​ ﻿﻿ (Uniformat); Material: Color RGB 000-076-255
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Custom: no; Article Description: Deksel FB CLT-C voor de vloerdoos FB CLT-B; Article Type: FB CLT-C; Assembly Code: ﻿﻿ ﻿ ​ ​﻿ ﻿ ﻿ ﻿ ​ ﻿﻿; Base Family Version: 23.08; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Description: Deksel FB CLT-C voor de vloerdoos FB CLT-B; EMCS Version: 5.0; ETIM Article Class: EC002601; Family Version: 23.08; GLN: 8712507100009; GTIN: 8712507475268; Keynote: ﻿﻿ ﻿ ​ ​﻿ ﻿ ﻿ ﻿ ​ ﻿﻿; Manufacturer: ABB; Manufacturer Art. No.: 1SPA007126F0502; Manufacturer URL: https://www.abbconnect.nl/details/index.aspx?id=1SPA007126F0502&languageCode=nl&country=nl; MEPcontent Class: JUNCTION_BOX; Model: FB CLT-C; Product Line: Hafobox; Revit Version: 2021; Type Comments: ﻿﻿ ﻿ ​ ​﻿ ﻿ ﻿ ﻿ ​ ﻿﻿; Type Name: FB CLT-C; URL: https://mep.trimble.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Blue: Color RGB 000-076-255
Type - Other - Category: Electrical Fixtures; Family Name: E_Floor Junction Box_Cover_MEPcontent_ABB_FB CLT-C_NL-NL_Shared
Type - Pset_JunctionBoxTypeCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB
Pset_EnvironmentalImpactIndicators - Reference: FB CLT-C
Pset_JunctionBoxTypeCommon - Reference: FB CLT-C
Constraints - Moves With Nearby Elements: no
Dimensions - Area: 0.0208625 m2; Volume: 0.0000443735 m3
Identity Data - Function Code: E6000; Mark: 11
Other - Family: E_Floor Junction Box_Cover_MEPcontent_ABB_FB CLT-C_NL-NL_Shared: FB CLT-C; Family and Type: E_Floor Junction Box_Cover_MEPcontent_ABB_FB CLT-C_NL-NL_Shared: FB CLT-C; Transparency Visible: yes; Type: E_Floor Junction Box_Cover_MEPcontent_ABB_FB CLT-C_NL-NL_Shared: FB CLT-C; Type Id: E_Floor Junction Box_Cover_MEPcontent_ABB_FB CLT-C_NL-NL_Shared: FB CLT-C
Phasing - Phase Created: 4. Prévoyez plus de 10 ans

# IfcJunctionBox: E_Floor Junction Box_MEPcontent_ABB_CLT_NL-NL:CLT, E_Floor Junction Box_MEPcontent_ABB_CLT_NL-NL:CLT:1375228
In: V00
Type - Material: Color RGB 000-076-255
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 45 mm; Height: 85 mm; Length: 360 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 180 deg; Rotation W-Axis Correction: 90 deg; Width: 45 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Identity Data - Article Description: Voor toepassing in CLT vloeren Zonder deksel FB CLT-C. Vloerdoos zonder deksel tbv CLT (massieve) vloeren en stekerbare oplossingen; Article Type: CLT; Base Family Version: 23.08; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Voor toepassing in CLT vloeren Zonder deksel FB CLT-C. Vloerdoos zonder deksel tbv CLT (massieve) vloeren en stekerbare oplossingen; EMCS Version: 5.0; ETIM Article Class: EC002601; Family Version: 23.08; GLN: 8712507100009; GTIN: 8712507475251; Manufacturer: ABB; Manufacturer Art. No.: 1SPA007126F0501; Manufacturer URL: https://new.abb.com/low-voltage/nl/producten/verdelers/installatiedozen/inbouwdozen/hollewanddozen/clt-vloerdoos; MEPcontent Class: JUNCTION_BOX; Model: CLT; OmniClass Number: 23.80.30.14.24; OmniClass Title: Junction Boxes; Product Line: Hafobox; Revit Version: 2021; Type Name: CLT; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Blue: Color RGB 000-076-255; White: Color RGB 255-226-181
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Conduit Connector 16mm: 16 mm; Conduit Connector 20mm: 20 mm; Conduit Connector 25mm: 25 mm; Family Name: E_Floor Junction Box_MEPcontent_ABB_CLT_NL-NL
Type - Pset_JunctionBoxTypeCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB
Pset_EnvironmentalImpactIndicators - Reference: CLT
Pset_JunctionBoxTypeCommon - Reference: CLT
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.0889053 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000235377 m3
Identity Data - Function Code: E6000; Mark: 6
Other - Family: E_Floor Junction Box_MEPcontent_ABB_CLT_NL-NL: CLT; Family and Type: E_Floor Junction Box_MEPcontent_ABB_CLT_NL-NL: CLT; Type: E_Floor Junction Box_MEPcontent_ABB_CLT_NL-NL: CLT; Type Id: E_Floor Junction Box_MEPcontent_ABB_CLT_NL-NL: CLT
Phasing - Phase Created: 4. Prévoyez plus de 10 ans
Visibility - Cover Visibility: yes; Separator Visibility: yes

# IfcJunctionBox: E_Floor Junction Box_Separator_MEPcontent_ABB_FB CLT-S_NL-NL_Shared:FB CLT-S (4)
In: V00
Type - Classification: ﻿﻿ ﻿ ﻿﻿﻿﻿﻿﻿ ﻿ ﻿ ﻿ ﻿ ﻿​ ​​ ​​ ​​ ﻿﻿ ​ ​​ ​​ ﻿ ﻿﻿ ﻿ ﻿ ﻿﻿ (Uniformat); Material: Color RGB 255-226-181
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Custom: no; Article Description: Scheidingschot FB CLT-S voor de vloerdoos FB CLT-B; Article Type: FB CLT-S; Assembly Code: ﻿﻿ ﻿ ﻿﻿﻿﻿﻿﻿ ﻿ ﻿ ﻿ ﻿ ﻿​ ​​ ​​ ​​ ﻿﻿ ​ ​​ ​​ ﻿ ﻿﻿ ﻿ ﻿ ﻿﻿; Base Family Version: 23.08; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Description: Scheidingschot FB CLT-S voor de vloerdoos FB CLT-B; EMCS Version: 5.0; ETIM Article Class: EC002601; Family Version: 23.08; GLN: 8712507100009; GTIN: 8712507475275; Keynote: ﻿﻿ ﻿ ﻿﻿﻿﻿﻿﻿ ﻿ ﻿ ﻿ ﻿ ﻿​ ​​ ​​ ​​ ﻿﻿ ​ ​​ ​​ ﻿ ﻿﻿ ﻿ ﻿ ﻿﻿; Manufacturer: ABB; Manufacturer Art. No.: 1SPA007126F0503; Manufacturer URL: https://www.abbconnect.nl/Details/Index.aspx/1SPA007126F0503?languageCode=nl&country=nl; MEPcontent Class: JUNCTION_BOX; Model: FB CLT-S; Product Line: Hafobox; Revit Version: 2021; Type Comments: ﻿﻿ ﻿ ﻿﻿﻿﻿﻿﻿ ﻿ ﻿ ﻿ ﻿ ﻿​ ​​ ​​ ​​ ﻿﻿ ​ ​​ ​​ ﻿ ﻿﻿ ﻿ ﻿ ﻿﻿; Type Name: FB CLT-S; URL: https://mep.trimble.com
Type - Materials and Finishes - White: Color RGB 255-226-181
Type - Other - Category: Electrical Fixtures; Family Name: E_Floor Junction Box_Separator_MEPcontent_ABB_FB CLT-S_NL-NL_Shared
Type - Pset_JunctionBoxTypeCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB
Pset_EnvironmentalImpactIndicators - Reference: FB CLT-S
Pset_JunctionBoxTypeCommon - Reference: FB CLT-S
Constraints - Elevation from Level: -73 mm; Moves With Nearby Elements: no; Offset from Host: -73 mm
Dimensions - Area: 0.00204849 m2; Volume: 0.000003744 m3; Wall Offset: 0 mm
Identity Data - Function Code: E6000
Other - Family: E_Floor Junction Box_Separator_MEPcontent_ABB_FB CLT-S_NL-NL_Shared: FB CLT-S; Family and Type: E_Floor Junction Box_Separator_MEPcontent_ABB_FB CLT-S_NL-NL_Shared: FB CLT-S; Type: E_Floor Junction Box_Separator_MEPcontent_ABB_FB CLT-S_NL-NL_Shared: FB CLT-S; Type Id: E_Floor Junction Box_Separator_MEPcontent_ABB_FB CLT-S_NL-NL_Shared: FB CLT-S
Phasing - Phase Created: 4. Prévoyez plus de 10 ans
Name (E_Floor Junction Box_Separator_MEPcontent_ABB_FB CLT-S_NL-NL_Shared:FB CLT-S:...) | Mark
1375229 | 7
1375230 | 8
1375231 | 9
1375232 | 10
